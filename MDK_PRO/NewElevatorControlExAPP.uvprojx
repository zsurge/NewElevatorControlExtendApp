# Keil uVision project NewElevatorControlExAPP.uvprojx, settings and files
target NewElevatorControlExAPP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NewElevatorControlExAPP +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: AutoRenameByVersion.exe ..\7Bin\NewElevatorControlExAPP.bin ..\4UserLayer\Version.c ..\Log\ModifyRecords.txt  NewElevatorControlEx
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\1McuLayer\STM32F4x7_ETH_Driver\inc;..\1McuLayer\CMSIS;..\1McuLayer\STM32F4xx_StdPeriph_Driver\inc;..\2LowLayer\LED;..\2LowLayer\USART;..\2LowLayer\FLASH;..\2LowLayer\TIME;..\2LowLayer\KEY;..\2LowLayer\FLASH\inc;..\2LowLayer\BEEP;..\2LowLayer\DigitalTube;..\2LowLayer\BSP;..\2LowLayer\ETHERNET;..\2LowLayer\WDG;..\2LowLayer\DIPSWITCH;..\2LowLayer\DS1302;..\2LowLayer\RTC;..\2LowLayer\READER;..\2LowLayer\AT24Cxx;..\2LowLayer\SUART;..\3MiddleLayer\sys;..\3MiddleLayer\delay;..\3MiddleLayer\easyflash\inc;..\3MiddleLayer\ini;..\3MiddleLayer\stmflash;..\3MiddleLayer\ymodem;..\3MiddleLayer\cjson;..\3MiddleLayer\malloc;..\3MiddleLayer\easylogger\inc;..\3MiddleLayer\mqtt;..\4UserLayer;..\5FreeRTOS\portable\RVDS\ARM_CM4F;..\5FreeRTOS\include;..\6LWIP;..\6LWIP\arch;..\6LWIP\lwip-1.4.1\src\include;..\6LWIP\lwip-1.4.1\src\include\ipv4;..\6LWIP\lwip-1.4.1\src\include\netif;..\6LWIP\lwip-1.4.1\src\include\lwip;..\6LWIP\lwip_app\lwip_comm;..\4UserLayer\Apps;..\4UserLayer\Task;..\3MiddleLayer\des;..\3MiddleLayer\cm_backtrace
  memory RVCT4: ROM 0x8030000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Log
    ../Log/: ModifyRecords.txt
  group UserLayer
    ../4UserLayer/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../4UserLayer/Apps/: errorcode.c eth_cfg.c mqtt_app.c test.c tool.c version.c CmdHandle.c FloorDataProc.c LocalData.c calcDevNO.c quickSort.c
  group Task
    ../4UserLayer/Task/: BarCode_Task.c Comm_Task.c HandShake_Task.c Hc595_Task.c Key_Task.c Led_Task.c Mqtt_Task.c Reader_Task.c Watchdog_Task.c DataProcess_Task.c
  group MiddleLayer
    ../3MiddleLayer/delay/: delay.c
    ../3MiddleLayer/sys/: sys.c
    ../3MiddleLayer/ini/: ini.c
    ../3MiddleLayer/ymodem/: ymodem.c
    ../3MiddleLayer/stmflash/: stmflash.c
    ../3MiddleLayer/cjson/: cJSON.c jsonUtils.c
    ../3MiddleLayer/malloc/: malloc.c
    ../3MiddleLayer/des/: des.c
  group DriveLayer
    ../2LowLayer/BEEP/: bsp_beep.c
    ../2LowLayer/DigitalTube/: bsp_DigitalTube.c
    ../2LowLayer/FLASH/: bsp_spi_flash.c
    ../2LowLayer/INFRARED/: bsp_infrared.c
    ../2LowLayer/KEY/: bsp_key.c
    ../2LowLayer/LED/: bsp_led.c
    ../2LowLayer/TIME/: bsp_time.c bsp_tim_pwm.c
    ../2LowLayer/BSP/: bsp.c
    ../2LowLayer/WDG/: bsp_iwdg.c
    ../2LowLayer/READER/: bsp_Wiegand.c
    ../2LowLayer/USART/: bsp_uart_fifo.c bsp_usart5.c bsp_usart6.c ringbuff.c
    ../2LowLayer/ETHERNET/: lan8720.c
    ../2LowLayer/DIPSWITCH/: bsp_dipSwitch.c
    ../2LowLayer/RTC/: bsp_rtc.c
    ../2LowLayer/DS1302/: bsp_ds1302.c
    ../2LowLayer/AT24Cxx/: bsp_24Cxx.c bsp_i2c.c bsp_MB85RC128.c
  group StdPeriphDriver
    ../1McuLayer/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_pwr.c
    ../1McuLayer/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ../1McuLayer/CMSIS/: startup_stm32f40_41xxx.s
  group FreeRTOS_CORE
    ../5FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../5FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../5FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS_CLI
    ../5FreeRTOS/cli/: FreeRTOS_CLI.c UARTCommandConsole.c CLI_Serial.c cmd_fun.c
  group sfud
    ../2LowLayer/FLASH/src/: sfud.c sfud_sfdp.c
    ../2LowLayer/FLASH/port/: sfud_port.c
  group EasyFlash
    ../3MiddleLayer/easyflash/src/: easyflash.c ef_utils.c ef_env.c ef_iap.c
    ../3MiddleLayer/easyflash/port/: ef_port.c
  group EasyLogger
    ../3MiddleLayer/easylogger/port/: elog_port.c
    ../3MiddleLayer/easylogger/src/: elog_utils.c elog.c
  group LWIP-APP
    ../6LWIP/lwip_app/lwip_comm/: lwip_comm.c LwipCom_Task.c LwipDHCP_Task.c
  group LWIP-API
    ../6LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP-CORE
    ../6LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP-CORE-IPV4
    ../6LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP-NETIF
    ../6LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-ARCH
    ../6LWIP/arch/: sys_arch.c
  group Mqtt
    ../3MiddleLayer/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c
  group cm_backtrace
    ../3MiddleLayer/cm_backtrace/: cm_backtrace.c
    ../3MiddleLayer/cm_backtrace/fault_handler/keil/: cmb_fault.S
